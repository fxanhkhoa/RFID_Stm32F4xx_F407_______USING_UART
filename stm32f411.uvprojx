# Keil uVision project stm32f411.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f411
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\stm32f4xx_peripheral_library\inc;.\stm32f4xx_peripheral_library\src;..\stm32f411;.\Include;..\RFID_Stm32F4xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Source
    ./: main.cpp
  group Include
    ./Include/: U_Print.cpp AT_Command.cpp DS1307.cpp function.cpp 25lc256.cpp
  group stm32f4xx_periph_lib
    ./stm32f4xx_peripheral_library/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c startup_stm32f407xx.s
